# Keil uVision project DWS3000_Bootloader.uvprojx, settings and files
target DWS3000_Bootloader (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32L412KBUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=3 OneElfS=1 uC99=1
  c define: STM32L412xx
  c include: ..\shared\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\bootloader_simple.sct
  group Source
    ./: bootloader.c
  group Startup
    ../shared/startup/: startup_stm32l412xx.s
