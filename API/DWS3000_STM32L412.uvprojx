# Keil uVision project DWS3000_STM32L412.uvprojx, settings and files
target DWS3000_STM32L412 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32L412KBUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: DWS3000_STM32L412 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1
  c define: USE_HAL_DRIVER, STM32L412xx
  c include: .\Inc;.\Src;.\Src\platform;.\Src\decadriver;.\Src\examples\examples_info;.\Src\examples\shared_data;.\Src\examples\ex_10a_downlink_tag;.\Src\examples\ex_10b_downlink_anchor;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32L4xx\Include;.\Drivers\STM32L4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: .\DWS3000_STM32L412.sct
  group Application
    ./Src/: main.c
  group DW3000_Driver
    ./Src/decadriver/: deca_device.c
    ./Src/: config_options.c
  group Examples
    ./Src/examples/examples_info/: example_info.c
    ./Src/examples/shared_data/: shared_functions.c
    ./Src/examples/ex_09b_fusion_anchor/: fusion_anchor.c gateway_cmd.c
  group Platform
    ./Src/platform/: port.c deca_spi.c deca_mutex.c deca_sleep.c
  group MAC
    ./Src/MAC_802_15_4/: mac_802_15_4.c
    ./Src/MAC_802_15_8/: mac_802_15_8.c
  group BSP
    ./Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c
  group HAL_Driver
    ./Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c
  group Startup
    ./startup/: startup_stm32l412xx.s
