# Keil uVision project DWS3000_Anchor_Master.uvprojx, settings and files
target DWS3000_Anchor_Master (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32L412KBUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: anchor_master +hex
  AfterMake: powershell -ExecutionPolicy Bypass -File "..\scripts\rename_fw.ps1" "#H" "#L" "Anchor_Master" "..\shared\shared_data\firmware_version.h"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1
  c define: USE_HAL_DRIVER, STM32L412xx, TEST_FUSION_ANCHOR
  c include: ..\shared\Inc;..\shared\Drivers\CMSIS\Include;..\shared\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\shared\Drivers\STM32L4xx_HAL_Driver\Inc;..\shared\decadriver;..\shared\platform;..\shared\MAC_802_15_4;..\shared\MAC_802_15_8;..\shared\shared_data;..\shared\examples_info;..\shared\config;..\shared\fusion_anchor;..\shared\fusion_tag;..\shared\system;..\shared\downlink;.\Src;..\shared\gw_ota
  asm include: ..\shared\Inc;..\shared\Drivers\CMSIS\Include;..\shared\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\shared\Drivers\STM32L4xx_HAL_Driver\Inc;..\shared\decadriver;..\shared\platform;..\shared\MAC_802_15_4;..\shared\MAC_802_15_8;..\shared\shared_data;..\shared\examples_info;..\shared\config;..\shared\fusion_anchor;..\shared\fusion_tag;..\shared\system;..\shared\downlink;.\Src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: .\DWS3000_Anchor.sct
  group Application
    ./Src/: main.c
  group DW3000_Driver
    ../shared/decadriver/: deca_device.c
    ../shared/config/: config_options.c
  group Examples
    ../shared/examples_info/: example_info.c
    ../shared/shared_data/: shared_functions.c clock_sync.c
    ../shared/fusion_anchor/: fusion_anchor.c
    ../shared/gw_ota/: gw_ota.c
  group Platform
    ../shared/platform/: port.c deca_spi.c deca_mutex.c deca_sleep.c
  group MAC
    ../shared/MAC_802_15_4/: mac_802_15_4.c
    ../shared/MAC_802_15_8/: mac_802_15_8.c
  group BSP
    ./Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c
    ../shared/system/: system_stm32l4xx.c
  group HAL_Driver
    ../shared/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c
    ../API/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c
  group Startup
    ../shared/startup/: startup_stm32l412xx.s
